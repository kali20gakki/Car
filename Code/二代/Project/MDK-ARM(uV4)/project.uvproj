# Keil uVision project project.uvproj, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429BI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,ARM_MATH_CM4,__FPU_PRESENT
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User\bsp\inc;..\..\User\bsp;..\..\User;..\..\uCOS-III\uC-CPU;..\..\uCOS-III\uC-CPU\ARM-Cortex-M4\RealView;..\..\uCOS-III\uC-LIB;..\..\uCOS-III\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\..\uCOS-III\uCOS-III\Source;..\..\uCOS-III\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\..\User\fonts;..\..\User\FatFS\src;..\..\emWin\Include;..\..\emWin\emWinTask;..\..\emWin\Config;..\..\emWin\PNG;..\..\emWin\HanZi;..\..\emWin\STemWin_Addons;..\..\Libraries\STM32F10x_DSP_Lib\inc;..\..\User\mp3\pub;..\..\User\mp3\real;..\..\User\malloc;..\..\User\libapp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: main.c includes.h app_cfg.h cpu_cfg.h lib_cfg.h os_cfg.h cpu_bsp.c os_cfg_app.h os_app_hooks.c os_app_hooks.h
  group AppLib
    ../../User/libapp/: app_user_lib.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32f4xx_it.c stm32f4xx_assert.c
    ../../User/bsp/src/: bsp_led.c bsp_key.c bsp_adc.c bsp_beep.c bsp_ext_io.c bsp_sdio_sd.c bsp_uart_fifo.c bsp_tim_pwm.c bsp_i2c_gpio.c bsp_adc_dso.c bsp_dac_wave.c bsp_fmc_sdram.c bsp_eeprom_24xx.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_usart.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_fmc.c stm32f4xx_ltdc.c stm32f4xx_dma2d.c stm32f4xx_sdio.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_pwr.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_adc.c stm32f4xx_dac.c
  group CMSIS
    ../../User/bsp/: system_stm32f4xx.c
  group uC/CPU
    ../../uCOS-III/uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
    ../../uCOS-III/uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../../uCOS-III/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../uCOS-III/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uC/OS-III Source
    ../../uCOS-III/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_mon.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uC/OS-III Port
    ../../uCOS-III/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group Fonts
    ../../User/fonts/: asc12.c asc16.c fonts.h hz12.c hz16.c hz24.c hz32.c song16.c NI7SEG90.c ra8875_asc_width.c
  group LCD_Driver
    ../../User/bsp/src/: param.c bsp_tft_429.c bsp_tft_lcd.c bsp_touch.c bsp_gt811.c bsp_ts_ft5x06.c TOUCH_STMPE811.c
  group GUI_X
    ../../emWin/GUI_X/: GUI_X_uCOS-III.c
  group GUI/Config
    ../../emWin/Config/: GUIConf.c GUIConf.h LCDConf_Lin_Template.c LCDConf_Lin_Template.h
  group GUI/DEMO
    ../../emWin/emWinTask/: MainTask.c MainTask.h DSO_Init.c DSO_DrawCursorV.c DSO_DrawCursorH.c DSO_DrawBakFrame.c DSO_AmplitudeDlg.c DSO_Status1Dlg.c DSO_Status2Dlg.c DSO_ScaleDlg.c DSO_SysInfoDlg.c DSO_MeasureDlg.c DSO_AdcDlg.c DSO_DacDlg.c DSO_MathDlg.c DSO_SettingDlg.c DSO_MultiMeter.c DSO_WaveProcess.c DSO_FirFilter_Step1KHz.c DSO_FirFilter_Step10KHz.c DSO_FirFilter_Step100KHz.c
  group GUI/ICON
    ../../emWin/ICON/: Return.c Settings.c
  group GUI/Lib
    ../../emWin/STemWin_Addons/: ST_GUI_Addons.h STemWin_Addons_KEIL.lib
    ../../emWin/GUILib/: STemWin532_CM4_OS_Keil_ot.lib
  group DSP/Lib
    ../../Libraries/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group Malloc
    ../../User/malloc/: rt_Memory.c rt_Memory.h
  group FatFS
    ../../User/FatFS/src/: diskio.c diskio.h ffconf.h ff.c ff.h integer.h
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt 03.例程操作说明.txt
