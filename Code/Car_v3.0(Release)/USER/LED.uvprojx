# Keil uVision project LED.uvprojx, settings and files
target LED (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=2 oTime=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\HARDWARE\TIMER;..\HARDWARE\SERVO;..\HARDWARE\USART3;..\HARDWARE\MOTOR;..\HARDWARE\BEEP;..\HARDWARE\ENCODER;..\HARDWARE\MESSAGE;..\HARDWARE\CONTROL;..\HARDWARE\DataScope_DP;..\HARDWARE\MOVMENT;..\HARDWARE\SENSOR;..\HARDWARE\ANO;..\HARDWARE\OLED;..\HARDWARE\KEY;..\HARDWARE\UART5;..\HARDWARE\TASK;..\HARDWARE\HC05;..\HARDWARE\STRATEGY;..\HARDWARE\ACTION;..\HARDWARE\USART2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/SERVO/: servo.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/MESSAGE/: message.c
    ../HARDWARE/SENSOR/: sensor.c
    ../HARDWARE/CONTROL/: control.c
    ../HARDWARE/MOVMENT/: move.c
    ../HARDWARE/ANO/: ano.c
    ../HARDWARE/OLED/: myiic.c oled.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TASK/: task.c
    ../HARDWARE/UART5/: uart5.c
    ../HARDWARE/HC05/: hc05.c
    ../HARDWARE/STRATEGY/: strategy.c
    ../HARDWARE/ACTION/: action.c
    ../HARDWARE/USART2/: usart2.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_exti.c
